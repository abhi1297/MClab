<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\Palindrome.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\stringrev.ewp</path>
    </project>
    <batchBuild />
</workspace>
